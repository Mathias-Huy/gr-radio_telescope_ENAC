options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Spectromètre
  states: {}

blocks:
- name: Amplitude
  id: variable_qtgui_range
  parameters:
    start: '0.001'
    step: '0.001'
    stop: '1'
    value: '0.001'
  states: {}
- name: CN0_dB
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_1@0
    start: '-100'
    step: '1'
    stop: '100'
    value: '100'
  states: {}
- name: Delay
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: custom_window
  id: variable
  parameters:
    value: sinc*np.hamming(4*lenght_vec)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1420e6
  states: {}
- name: lenght_vec
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: nb_integration
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_1@0
    start: '1'
    step: '1'
    stop: '50'
    value: '25'
  states: {}
- name: qt_chooser_0
  id: variable_qtgui_chooser
  parameters:
    gui_hint: qtgui_tab_widget_1@0
    label: 'Calibration Type '
    label0: '"Hot"'
    label1: '"Cold"'
    label2: '"Calibrated"'
    label3: '"Non Calibrated"'
    num_opts: '4'
    option0: '"Hot"'
    option1: '"Cold"'
    option2: '"Caibrated"'
    option3: '"Non_calibrated"'
    orient: Qt.QHBoxLayout
    type: string
    value: '"Hot"'
    widget: radio_buttons
  states: {}
- name: qtgui_chooser_1
  id: variable_qtgui_chooser
  parameters:
    gui_hint: qtgui_tab_widget_1@0
    label: Window
    label0: Hanning
    label1: Hamming
    label2: Blackman Harris
    num_opts: '3'
    option0: hanning
    option1: hamming
    option2: blackman_harris
    type: string
    value: hamming
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {state: disabled}
- name: sinc
  id: variable
  parameters:
    value: np.sinc(sinc_sample_locations/np.pi)
  states: {}
- name: sinc_sample_locations
  id: variable
  parameters:
    value: np.arange(-np.pi*4/2.0, np.pi*4/2.0, np.pi/lenght_vec)
  states: {}
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    gui_hint: qtgui_tab_widget_1@0
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: (1/(2*10**(CN0_dB/10)))**0.5
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
    vlen: lenght_vec
  states: {state: disabled}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: lenght_vec
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '4096'
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '4096'
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Delay
    type: complex
  states: {state: disabled}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: 3*Delay
    type: complex
  states: {state: disabled}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: 2*Delay
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/kira/Documents/Projet SAT/gr-radio_telescope_ENAC/Enregistrement/Test
    type: complex
    vlen: '4096'
  states: {state: disabled}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: '1'
    type: float
    vlen: lenght_vec
  states: {state: disabled}
- name: blocks_integrate_xx_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: '16'
    type: float
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[2*lenght_vec:3*lenght_vec]
    type: complex
    vlen: lenght_vec
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[lenght_vec:2*lenght_vec]
    type: complex
    vlen: lenght_vec
  states: {state: disabled}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[0:lenght_vec]
    type: complex
    vlen: lenght_vec
  states: {state: disabled}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[-lenght_vec:]
    type: complex
    vlen: lenght_vec
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/lenght_vec
    type: complex
    vlen: lenght_vec
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/4096
    type: complex
    vlen: '4096'
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: '4096'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: '4096'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '4096'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: lenght_vec
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: lenght_vec
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: lenght_vec
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_3
  id: blocks_stream_to_vector
  parameters:
    num_items: lenght_vec
    type: complex
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '4096'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(4096)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: lenght_vec
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(lenght_vec)
  states: {state: disabled}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: '4096'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(4096)
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: airspy=0,bias=0,pack=0
    bb_gain0: '0'
    freq0: freq
    gain0: '21'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}
- name: qtgui_tab_widget_1
  id: qtgui_tab_widget
  parameters:
    label0: Spectre
    label1: Etat Système
    num_tabs: '2'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: qtgui_tab_widget_1@0
    name: '"PFB"'
    vlen: '4096'
    x_axis_label: '"Power"'
    x_start: '0'
    x_step: '1.0'
    x_units: '"Hz"'
    y_axis_label: '"Fréquence"'
    y_units: '"dB"'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.05'
    grid: 'True'
    gui_hint: qtgui_tab_widget_1@0
    label1: Spectrum
    name: '"Spectrum"'
    vlen: vec_length
    width1: '2'
    x_axis_label: '"Frequency (MHz)"'
    x_start: (freq - samp_rate/2)/1e6
    x_step: (samp_rate/vec_length)/1e6
    x_units: '"MHz"'
    y_axis_label: '"Signal"'
  states: {}
- name: qtgui_vector_sink_f_0_0_1_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.05'
    grid: 'True'
    gui_hint: qtgui_tab_widget_1@0
    label1: Spectrum
    name: No Trait
    vlen: vec_length
    width1: '2'
    x_axis_label: '"Frequency (MHz)"'
    x_start: (freq - samp_rate/2)/1e6
    x_step: (samp_rate/vec_length)/1e6
    x_units: '"MHz"'
    y_axis_label: '"Signal"'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    color1: '"green"'
    grid: 'True'
    gui_hint: qtgui_tab_widget_1@0
    label1: 'PFB '
    label2: FFT
    name: '"Spectre Intégré"'
    nconnections: '2'
    vlen: '4096'
    x_start: '0'
    x_step: '1'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_1_3
  id: qtgui_vector_sink_f
  parameters:
    average: '0.2'
    color1: '"green"'
    gui_hint: qtgui_tab_widget_1@1
    label1: 'PFB '
    name: '"Tsys"'
    vlen: '4096'
    x_start: '0'
    x_step: '1'
  states: {}
- name: qtgui_vector_sink_f_0_1_3_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.2'
    color1: '"green"'
    gui_hint: qtgui_tab_widget_1@1
    label1: 'PFB '
    name: '"Gsys"'
    vlen: '4096'
    x_start: '0'
    x_step: '1'
  states: {}
- name: qtgui_vector_sink_f_2
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.2'
    grid: 'True'
    gui_hint: qtgui_tab_widget_1@0
    name: '"FFT Classique"'
    vlen: '4096'
    x_axis_label: '"Fréquence"'
    x_start: '0'
    x_step: '1.0'
    x_units: '"Hz"'
    y_axis_label: '"Power"'
    y_units: '"dB"'
  states: {state: disabled}
- name: radio_telescope_ENAC_Calibration_0
  id: radio_telescope_ENAC_Calibration
  parameters:
    calibration_type: qt_chooser_0
    sample_rate: int(samp_rate)
    vec_len: '4096'
  states: {}
- name: radio_telescope_ENAC_Gausian_Signal_0
  id: radio_telescope_ENAC_Gausian_Signal
  parameters:
    amplitude: Amplitude
    carrier_frequency: '1000'
    samp_rate: samp_rate
    sigma2: '1e-6'
  states: {state: disabled}
- name: radio_telescope_ENAC_Integration_0_0
  id: radio_telescope_ENAC_Integration
  parameters:
    nb_integration: nb_integration
    vec_len: '4096'
  states: {}
- name: radio_telescope_ENAC_PFB_0
  id: radio_telescope_ENAC_PFB
  parameters:
    num_taps: '4'
    vec_len: '4096'
    window: qtgui_chooser_1
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_1, '0']
- [blocks_add_xx_0, '0', fft_vxx_0_0, '0']
- [blocks_add_xx_1, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_3, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_2, '0']
- [blocks_delay_0_2, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_integrate_xx_0_0_0, '0', radio_telescope_ENAC_Integration_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_3, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0_0_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0_1, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_vector_sink_f_0_0_1_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_vector_sink_f_0_1, '1']
- [blocks_nlog10_ff_0_0, '0', qtgui_vector_sink_f_2, '0']
- [blocks_stream_to_vector_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0, '0', radio_telescope_ENAC_PFB_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_multiply_const_vxx_3, '0']
- [blocks_stream_to_vector_0_2, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_stream_to_vector_0_3, '0', blocks_multiply_const_vxx_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [fft_vxx_0_1, '0', blocks_multiply_const_xx_0_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [radio_telescope_ENAC_Calibration_0, '0', blocks_nlog10_ff_0, '0']
- [radio_telescope_ENAC_Calibration_0, '1', qtgui_vector_sink_f_0_1_3, '0']
- [radio_telescope_ENAC_Calibration_0, '2', qtgui_vector_sink_f_0_1_3_0, '0']
- [radio_telescope_ENAC_Gausian_Signal_0, '0', blocks_add_xx_1, '0']
- [radio_telescope_ENAC_Integration_0_0, '0', radio_telescope_ENAC_Calibration_0, '0']
- [radio_telescope_ENAC_PFB_0, '0', fft_vxx_0, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
